options:
  parameters:
    id: rx_capture
    title: 'ATSC 3.0 receiver: capture file to IP datagrams'
    author: gr-atsc3rx
    generate_options: no_gui
    output_language: python
    run_options: run
    description: Capture Source -> Frame Sync -> Frame Decoder -> ALP Decap -> UDP.
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 6.912e6
    comment: 'ATSC 3.0''s own rate: no resampler'
  states: {}
- name: receiver_dir
  id: parameter
  parameters:
    label: Reference receiver (Python phase)
    type: str
    value: '""'
    short_id: r
    comment: empty = ATSC3_RECEIVER_DIR
  states: {}
- name: procs
  id: parameter
  parameters:
    label: Worker processes (CTI/LDM)
    type: intx
    value: '4'
    short_id: p
  states: {}
- name: capture
  id: parameter
  parameters:
    label: Capture file (.cs16 / .cf32)
    type: str
    value: '"capture.cs16"'
    short_id: c
  states: {}
- name: src
  id: atsc3rx_capture_source
  parameters:
    path: capture
    fmt: ''
    realtime_rate: '0'
    comment: goes quiet, not finished, at end of file
  states: {}
- name: show
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: sync
  id: atsc3rx_frame_sync
  parameters:
    samp_rate: samp_rate
    receiver_dir: receiver_dir
    fe_threads: '8'
    drop_when_behind: 'False'
    settle_sec: '0'
    inline: 'False'
    comment: bootstrap -> L1 -> plan; one PDU per frame
  states: {}
- name: dec
  id: atsc3rx_frame_decoder
  parameters:
    receiver_dir: receiver_dir
    threads: '16'
    iters: '50'
    procs: procs
    comment: OFDM, de-interleave, LDPC, BCH
  states: {}
- name: alp
  id: atsc3rx_alp_decap
  parameters:
    receiver_dir: receiver_dir
    comment: link layer -> IP datagrams
  states: {}
- name: udp
  id: atsc3rx_dg_udp_sink
  parameters:
    host: ''
    interface: 127.0.0.1
    ttl: '0'
    comment: 'as broadcast: multicast, TTL 0'
  states: {}

connections:
- [src, '0', sync, '0']
- [sync, plan, show, print]
- [sync, frames, dec, frames]
- [sync, plan, dec, plan]
- [dec, feedback, sync, feedback]
- [dec, bb, alp, bb]
- [alp, datagrams, udp, datagrams]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
