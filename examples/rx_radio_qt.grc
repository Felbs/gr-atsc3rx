options:
  parameters:
    id: rx_radio_qt
    title: 'ATSC 3.0 receiver: radio to IP datagrams'
    author: gr-atsc3rx
    generate_options: qt_gui
    output_language: python
    description: A SoapySDR radio through the receiver, with the status panel.
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 6.912e6
    comment: 'ATSC 3.0''s own rate: no resampler'
  states: {}
- name: receiver_dir
  id: parameter
  parameters:
    label: Reference receiver (Python phase)
    type: str
    value: '""'
    short_id: r
    comment: empty = ATSC3_RECEIVER_DIR
  states: {}
- name: procs
  id: parameter
  parameters:
    label: Worker processes (CTI/LDM)
    type: intx
    value: '4'
    short_id: p
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Channel centre (Hz)
    type: eng_float
    value: 600e6
    short_id: f
  states: {}
- name: driver
  id: parameter
  parameters:
    label: SoapySDR driver
    type: str
    value: '"sdrplay"'
    short_id: d
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna port
    type: str
    value: '""'
    short_id: a
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Overall gain (dB)
    type: eng_float
    value: '30'
    short_id: g
    comment: or tune the elements with gr-rxtune
  states: {}
- name: src
  id: soapy_custom_source
  parameters:
    driver: driver
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    center_freq0: freq
    bandwidth0: 8e6
    antenna0: antenna
    gain0: gain
    minoutbuf: '8388608'
    comment: 'a second of buffer: start-up is the hungry moment'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"carrier (baseband)"'
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    average: '0.05'
    gui_hint: 0,0,1,1
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"waterfall"'
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    gui_hint: 0,1,1,1
  states: {}
- name: panel
  id: atsc3rx_status_panel
  parameters:
    label: ATSC 3.0 receiver
    show_plan: show_plan
    gui_hint: 1,0,1,2
  states: {}
- name: show_plan
  id: parameter
  parameters:
    label: Show the PLP layout
    type: intx
    value: '1'
    short_id: s
  states: {}
- name: sync
  id: atsc3rx_frame_sync
  parameters:
    samp_rate: samp_rate
    receiver_dir: receiver_dir
    fe_threads: '8'
    drop_when_behind: 'True'
    settle_sec: '2.0'
    inline: 'False'
    comment: bootstrap -> L1 -> plan; one PDU per frame
  states: {}
- name: dec
  id: atsc3rx_frame_decoder
  parameters:
    receiver_dir: receiver_dir
    threads: '16'
    iters: '50'
    procs: procs
    comment: OFDM, de-interleave, LDPC, BCH
  states: {}
- name: alp
  id: atsc3rx_alp_decap
  parameters:
    receiver_dir: receiver_dir
    comment: link layer -> IP datagrams
  states: {}
- name: udp
  id: atsc3rx_dg_udp_sink
  parameters:
    host: ''
    interface: 127.0.0.1
    ttl: '0'
    comment: 'as broadcast: multicast, TTL 0'
  states: {}

connections:
- [src, '0', sync, '0']
- [src, '0', spectrum, '0']
- [src, '0', waterfall, '0']
- [sync, plan, panel, plan]
- [dec, quality, panel, quality]
- [sync, frames, dec, frames]
- [sync, plan, dec, plan]
- [dec, feedback, sync, feedback]
- [dec, bb, alp, bb]
- [alp, datagrams, udp, datagrams]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
